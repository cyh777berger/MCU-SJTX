# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h DHT11.c DHT11.h send.c send.h dianji.c dianji.h delay.c delay.h ADC0832.c ADC0832.h MatrixKey.c MatrixKey.h
